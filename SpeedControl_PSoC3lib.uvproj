# Keil uVision project SpeedControl_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: SpeedControl_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h LCD.c LCD.h LCD_PM.c LED_Status.c LED_Status.h LED_Status_aliases.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h hallEffectSensor.c hallEffectSensor.h hallEffectSensor_aliases.h hallTickCounter.c hallTickCounter.h hallTickCounter_PM.c hallEffect_ISR.c hallEffect_ISR.h hallTickTimer.c hallTickTimer.h hallTickTimer_PM.c deBounce.c deBounce.h pushButton.c pushButton.h pushButton_aliases.h LED.c LED.h LED_aliases.h SyncOut.c SyncOut.h SyncOut_aliases.h Pin_1.c Pin_1.h Pin_1_aliases.h PWM_GateVoltage.c PWM_GateVoltage.h PWM_GateVoltage_PM.c PWM_clock.c PWM_clock.h MOSFET_Gate.c MOSFET_Gate.h MOSFET_Gate_aliases.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: SpeedControl_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
